<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\priemNDMdsp.ewp</path>
  </project>
  <batchBuild />
</workspace>
